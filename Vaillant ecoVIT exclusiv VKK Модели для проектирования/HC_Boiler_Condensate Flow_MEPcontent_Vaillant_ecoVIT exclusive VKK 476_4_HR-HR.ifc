Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2019-07-26T11:54:04
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jul 26 11:54:04 2019 * Host: PROMAN1-RO-DE * Database: C:\Users\PRoman1\AppData\Local\Temp\{BE6C661A-26EE-4219-8037-EBE3F8114645}\ifc * Database version: 5507 * Database creation date: Fri Jul 26 11:54:02 2019 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Fri Jul 26 11:54:02 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jul 26 11:54:02 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcBoiler: ecoVIT exclusive VKK 476/4, HC_Boiler_Condensate Flow_MEPcontent_Vaillant_ecoVIT exclusiv_HR-HR:ecoVIT exclusive VKK 476/4:1327801
In: V00
Type - Material: Color RGB 244-244-244, Color RGB 116-051-029, Color RGB 121-121-121
Type - Dimensions - Condensate Connection: 32 mm; Depth: 691 mm; Gas Diameter: 19 mm; Height: 1257 mm; Hydronic Return Diameter: 25.4 mm; Hydronic Supply Diameter: 25.4 mm; Supply Air Diameter: 80 mm; Use Nominal Diameter: yes; Width: 570 mm
Type - Electrical - Loads - Voltage: 230 V
Type - Identity Data - Article Description: Podna ugradnja, 47 kW; Article Type: ecoVIT exclusive VKK 476/4; Base Family Version: 12.04; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Viskoučinkoviti kondenzacijski kotao; EMCS Version: 3.0; ETIM Article Class: EC011396; Family Version: 12.04; GTIN: 4024074569764; Manufacturer: Vaillant; Manufacturer Art. No.: 0010007522; Manufacturer URL: https://www.vaillant.hr/krajnji-korisnici/proizvodi/ecovit-exclusiv-vkk-int-844.html; MEPcontent Class: BOILER_CONDENSATE_FLOW; Model: ecoVIT exclusive VKK 476/4; OmniClass Number: 23.75.10.11.14; OmniClass Title: Hot Water Heat Generators; Product Line: ecoVIT exclusiv; Revit Version: 2018; Type Name: ecoVIT exclusive VKK 476/4; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Connection Pipes: Color RGB 116-051-029; Grey: Color RGB 121-121-121; White: Color RGB 244-244-244
Type - Mechanical - Tap Capacity at 40°C: 0 m3/s
Type - Mechanical - Loads - Heating Power: 505904
Type - Other - Category: Mechanical Equipment; Door Height: 354 mm; Door Total Height: 1067 mm; Family Name: HC_Boiler_Condensate Flow_MEPcontent_Vaillant_ecoVIT exclusiv_HR-HR; Insertion Point Offset: 0 mm
Type - Text - Pipe Type Category: M561
Pset_ManufacturerTypeInformation - Manufacturer: Vaillant
Constraints - Offset: 0 mm
Dimensions - Area: 8.83624 m2; Legs Height: 10 mm; Volume: 0.46659 m3
Electrical - Loads - Power: 0 W
Identity Data - Design Option: Main Model; Mark: 4
Mechanical - Drain Fixture Units: 0; Gas Flow: 0 m3/s; Hydronic Return 1 Flow: 0 m3/s; Hydronic Return 2 Flow: 0 m3/s; Hydronic Supply Flow: 0 m3/s; System Classification: Sanitary,Hydronic Return,Undefined,Hydronic Supply,Supply Air,Power
Mechanical - Flow - Supply Air Flow: 0 m3/s
Other - Family: HC_Boiler_Condensate Flow_MEPcontent_Vaillant_ecoVIT exclusiv_HR-HR: ecoVIT exclusive VKK 476/4; Family and Type: HC_Boiler_Condensate Flow_MEPcontent_Vaillant_ecoVIT exclusiv_HR-HR: ecoVIT exclusive VKK 476/4; Legs Offset: 10 mm; Type: HC_Boiler_Condensate Flow_MEPcontent_Vaillant_ecoVIT exclusiv_HR-HR: ecoVIT exclusive VKK 476/4; Type Id: HC_Boiler_Condensate Flow_MEPcontent_Vaillant_ecoVIT exclusiv_HR-HR: ecoVIT exclusive VKK 476/4
Phasing - Phase Created: 4. Plan over 10 years
Visibility - Show Service Area: no
